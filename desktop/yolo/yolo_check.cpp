// yolo_check: runs a YOLO operation table (generated by tools/yolo/yolo_gen_graph.py) on the exported
// test input and compares every layer output with the PyTorch reference. The targets yolo11_check
// and yolo26_check (CMakeLists.txt) set the model with the macros YOLO_NS, YOLO_BASE and YOLO_TABLE.
//
// usage: <target> <export folder> [--float] [--per-tensor]
//   the folder holds <base>_graph_weights.bin, input_640.bin and ref_layerNN_0.bin
//   (written by tools/yolo/yolo_export.py with the test photo).

#include <stdio.h>

#include <cmath>
#include <string>
#include <vector>

#include "TinyYolo.h"
#include "TinyYolo/graph/AnchorFree.h"
#include "TinyYolo/graph/Graph.h"
#include YOLO_TABLE

using namespace tinyyolo;

template <typename T>
static bool readRaw(const std::string& path, std::vector<T>& out) {
  FILE* f = fopen(path.c_str(), "rb");
  if (f == nullptr) return false;
  fseek(f, 0, SEEK_END);
  const long bytes = ftell(f);
  fseek(f, 0, SEEK_SET);
  out.resize((size_t)bytes / sizeof(T));
  const size_t got = fread(out.data(), sizeof(T), out.size(), f);
  fclose(f);
  return got == out.size();
}

static bool readFloats(const std::string& path, std::vector<float>& out) {
  FILE* f = fopen(path.c_str(), "rb");
  if (f == nullptr) return false;
  fseek(f, 0, SEEK_END);
  const long bytes = ftell(f);
  fseek(f, 0, SEEK_SET);
  out.resize((size_t)bytes / sizeof(float));
  const size_t got = fread(out.data(), sizeof(float), out.size(), f);
  fclose(f);
  return got == out.size();
}

int main(int argc, char** argv) {
  if (argc < 2) {
    fprintf(stderr, "usage: %s <export folder> [--float] [--per-tensor]\n", YOLO_BASE);
    return 2;
  }
  const std::string dir = argv[1];
  std::vector<float> weights, input;
  if (!readFloats(dir + "/" + YOLO_BASE "_graph_weights.bin", weights) || !readFloats(dir + "/input_640.bin", input)) {
    fprintf(stderr, "cannot read the weights or the input from %s\n", dir.c_str());
    return 1;
  }

  // The input is NCHW (1, 3, 640, 640); the graph works on HWC.
  Tensor image;
  if (image.allocate(Shape(640, 640, 3)) != Status::Ok) return 1;
  for (int c = 0; c < 3; ++c) {
    for (int y = 0; y < 640; ++y) {
      for (int x = 0; x < 640; ++x) image.at(y, x, c) = input[((size_t)c * 640 + y) * 640 + x];
    }
  }

  Graph graph;
  // Keep the outputs that are compared below (the layers and the head).
  std::vector<int> keep;
  for (int i = 0; i < YOLO_NS::kOutputCount; ++i) keep.push_back(YOLO_NS::kOutputs[i][1]);
  for (int l = 0; l < 6; ++l) keep.push_back(YOLO_NS::kDetectHeads[l / 2][l % 2]);
  // Int8 convolutions unless --float is given (the float graph is the reference).
  const bool use_int8 = !(argc > 2 && std::string(argv[2]) == "--float");
  // --per-tensor: the activation scales of each tensor (default: the shared scales of the fast table).
  bool per_tensor = false;
  for (int i = 2; i < argc; ++i) per_tensor = per_tensor || std::string(argv[i]) == "--per-tensor";
  std::vector<int8_t> qweights;
  std::vector<float> qscales;
  if (use_int8 && (!readRaw(dir + "/" + YOLO_BASE "_int8_weights.bin", qweights) ||
                   !readRaw(dir + "/" + YOLO_BASE "_int8_scales.bin", qscales))) {
    fprintf(stderr, "cannot read the int8 weights from %s\n", dir.c_str());
    return 1;
  }
  if (graph.begin(YOLO_NS::kOps, YOLO_NS::kOpCount, YOLO_NS::kParams, YOLO_NS::kParamCount, weights.data(),
                  YOLO_NS::kTensorCount, YOLO_NS::kInputId, keep.data(), (int)keep.size(),
                  use_int8 ? qweights.data() : nullptr, use_int8 ? qscales.data() : nullptr,
                  use_int8 ? (per_tensor ? YOLO_NS::kQuantPerTensor : YOLO_NS::kQuant) : nullptr) != Status::Ok) {
    return 1;
  }
  DotProductBackend backend;
  if (graph.run(backend, image) != Status::Ok) return 1;

  int failures = 0;
  for (int i = 0; i < YOLO_NS::kOutputCount; ++i) {
    const int layer = YOLO_NS::kOutputs[i][0];
    const Tensor& t = graph.tensor(YOLO_NS::kOutputs[i][1]);
    const Shape s = t.shape();
    char name[64];
    snprintf(name, sizeof(name), "/ref_layer%02d_0.bin", layer);
    std::vector<float> ref;
    if (!readFloats(dir + name, ref) || ref.size() != s.elements()) {
      printf("layer %2d: reference missing or of another size (%zu values, ours %zu)\n", layer, ref.size(),
             s.elements());
      ++failures;
      continue;
    }
    double worst = 0.0, range = 0.0;
    for (int c = 0; c < s.c; ++c) {
      for (int y = 0; y < s.h; ++y) {
        for (int x = 0; x < s.w; ++x) {
          const float r = ref[((size_t)c * s.h + y) * s.w + x];  // reference is NCHW
          const double d = std::fabs((double)t.at(y, x, c) - (double)r);
          if (d > worst) worst = d;
          if (std::fabs((double)r) > range) range = std::fabs((double)r);
        }
      }
    }
    printf("layer %2d: %3dx%3dx%4d  max abs error %.3e  (range %.3e)\n", layer, s.h, s.w, s.c, worst, range);
  }

  // The head: the dense output (1, 84, 8400) = (cx, cy, w, h, 80 class scores) per anchor.
  AnchorFreeLevel levels[3];
  for (int l = 0; l < 3; ++l) {
    levels[l].box = &graph.tensor(YOLO_NS::kDetectHeads[l][0]);
    levels[l].cls = &graph.tensor(YOLO_NS::kDetectHeads[l][1]);
    levels[l].stride = YOLO_NS::kDetectStrides[l];
    levels[l].reg_max = YOLO_NS::kDetectRegMax;
  }
  const int classes = YOLO_NS::kDetectClasses;
  int anchors = 0;
  for (int l = 0; l < 3; ++l) anchors += levels[l].box->shape().h * levels[l].box->shape().w;
  std::vector<float> dense((size_t)(4 + classes) * anchors);
  int a0 = 0;
  for (int l = 0; l < 3; ++l) {
    const Shape s = levels[l].box->shape();
    for (int y = 0; y < s.h; ++y) {
      for (int x = 0; x < s.w; ++x, ++a0) {
        float xyxy[4];
        decodeAnchorBox(levels[l], y, x, xyxy);
        dense[(size_t)0 * anchors + a0] = (xyxy[0] + xyxy[2]) * 0.5f;
        dense[(size_t)1 * anchors + a0] = (xyxy[1] + xyxy[3]) * 0.5f;
        dense[(size_t)2 * anchors + a0] = xyxy[2] - xyxy[0];
        dense[(size_t)3 * anchors + a0] = xyxy[3] - xyxy[1];
        for (int c = 0; c < classes; ++c) {
          dense[(size_t)(4 + c) * anchors + a0] = sigmoidValue(levels[l].cls->at(y, x, c));
        }
      }
    }
  }
  std::vector<float> head_ref;
  if (readFloats(dir + "/ref_layer23_0.bin", head_ref) && head_ref.size() == dense.size()) {
    double worst = 0.0;
    for (size_t i = 0; i < dense.size(); ++i) {
      const double d = std::fabs((double)dense[i] - (double)head_ref[i]);
      if (d > worst) worst = d;
    }
    printf("head (1, %d, %d): max abs error %.3e\n", 4 + classes, anchors, worst);
  } else {
    printf("head reference missing\n");
    ++failures;
  }

  // Detections, with the same thresholds as the reference predictor (conf 0.25, iou 0.7),
  // mapped back to the photo: the letterbox was scaled by `scale` and padded by 106 pixels.
  LetterboxInfo lb;
  lb.scale = 640.0f / 375.0f < 640.0f / 250.0f ? 640.0f / 375.0f : 640.0f / 250.0f;
  lb.pad_x = 0.0f;
  lb.pad_y = 106.0f;  // (640 - 427) / 2, the resized height is 427 pixels
  lb.source_w = 375;
  lb.source_h = 250;
  Detections candidates, detections;
  candidates.reserve(20000);
  detections.reserve(100);
  decodeAnchorFree(levels, 3, classes, 0.25f, 0.7f, candidates, detections);
  printf("detections: %d\n", detections.size());
  for (int i = 0; i < detections.size(); ++i) {
    const Detection& d = detections[i];
    float x1 = d.x, y1 = d.y, x2 = d.x + d.width, y2 = d.y + d.height;
    lb.toSource(x1, y1);
    lb.toSource(x2, y2);
    printf("  class %2d score %.3f box [%.1f, %.1f, %.1f, %.1f]\n", d.class_id, d.score, x1, y1, x2, y2);
  }
  return failures == 0 ? 0 : 1;
}
